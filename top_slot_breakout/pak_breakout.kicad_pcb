# Repository blackjetrock/psion-org2-top-slot

File README.md:

# psion-org2-top-slot
Psion Organiser 2 top slot interface

Top slot interface that can be attached to arbitrary hardware. RP2040 is used to present
a ROM with code that drives the hardware. The hardware is also interfaced using the datapak
code, using the extra states that drive hardware

## KiCad design top_slot_breakout/pak_breakout.kicad_pcb

Parts:
C2, C5: 100nF; C_0805_2012Metric
J1: Conn_02x08_Odd_Even; Psion_datapak_2x08_P2.54mm_Horizontal
J2: Conn_01x06_Female; PinSocket_1x06_P2.54mm_Vertical
J3: Conn_01x04_Female; PinHeader_1x04_P2.54mm_Vertical
J4, J15: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J5: Conn_01x03_Female; PinHeader_1x03_P2.54mm_Vertical
J6: Conn_01x12_Female; PinHeader_1x12_P2.54mm_Vertical
JP1, JP2, JP3, JP4: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R2, R19: R_Small; R_0805_2012Metric
R5, R7: 4k7; R_0805_2012Metric
U1, U2: 74LS245; SOIC-20W_7.5x12.8mm_P1.27mm
U3: Pico; RPi_Pico_SMD_TH

Connections:
3V3_EN: J2.5, U3.37 (3V3_EN)
AC: J1.14, J4.1
ADC_REF: J2.3, U3.35 (ADC_VREF)
GND: C2.2, C5.2, J1.9, J2.1, J5.2, J6.1, JP1.2, JP2.2, R2.2, U1.10 (GND), U1.19 (CE), U2.10 (GND), U2.19 (CE), U3.3 (GND), U3.8 (GND), U3.13 (GND), U3.18 (GND), U3.23 (GND), U3.28 (GND), U3.33 (AGND), U3.38 (GND), U3.42 (GND); also elsewhere on the board
I2C_SCLK: J3.2, R7.2, U3.22 (GPIO17)
I2C_SDA: J3.1, R5.2, U3.34 (GPIO28_ADC2)
IO0: J6.2, U3.1 (GPIO0)
IO1: J6.3, U3.2 (GPIO1)
IO2: J6.4, U3.7 (GPIO5)
IO3: J6.5, U3.21 (GPIO16)
IO4: J6.6, U3.24 (GPIO18)
IO5: J6.7, U3.25 (GPIO19)
IO6: J4.2, J6.8, U3.26 (GPIO20)
IO7: J6.9, J15.2
IP_CLK: J6.11, U3.27 (GPIO21); also elsewhere on the board
LS_DIR: R19.2, U2.1 (A->B), U3.32 (GPIO27_ADC1)
unnamed: J3.3, JP1.1, JP3.1
unnamed: J3.4, JP2.1, JP4.1
unnamed: J5.1, U3.43 (SWDIO)
unnamed: J5.3, U3.41 (SWCLK)
unnamed: J15.1, R1.2, R2.1
OP_CLK: J6.10, U3.29 (GPIO22); also elsewhere on the board
P_SCLK: U1.14 (B4), U3.6 (GPIO4)
P_SD0: U2.18 (B0), U3.11 (GPIO8); also elsewhere on the board
P_SD1: U2.17 (B1), U3.12 (GPIO9); also elsewhere on the board
P_SD2: U2.16 (B2), U3.14 (GPIO10); also elsewhere on the board
P_SD3: U2.15 (B3), U3.15 (GPIO11); also elsewhere on the board
P_SD4: U2.14 (B4), U3.16 (GPIO12); also elsewhere on the board
P_SD5: U2.13 (B5), U3.17 (GPIO13); also elsewhere on the board
P_SD6: U2.12 (B6), U3.19 (GPIO14); also elsewhere on the board
P_SD7: U2.11 (B7), U3.20 (GPIO15); also elsewhere on the board
P_SMR: U1.15 (B3), U3.10 (GPIO7)
P_SOE: U1.16 (B2), U3.9 (GPIO6)
P_SPGM: U1.18 (B0), U3.4 (GPIO2)
P_SS: U1.17 (B1), U3.5 (GPIO3)
RUN: J2.2, U3.30 (RUN)
SCLK: J1.10, U1.6 (A4)
SD0: J1.2, U2.2 (A0)
SD1: J1.4, U2.3 (A1)
SD2: J1.6, U2.4 (A2)
SD3: J1.8, U2.5 (A3)
SD4: J1.7, U2.6 (A4)
SD5: J1.5, U2.7 (A5)
SD6: J1.3, U2.8 (A6)
SD7: J1.1, U2.9 (A7)
SMR: J1.16, U1.5 (A3)
SOE: J1.15, U1.4 (A2)
SS: J1.12, U1.3 (A1)
VB: J1.11, R1.1
VBUS: J2.4, U3.40 (VBUS)

Notes on the sheet:
Top Slot Adapter Breakout Board Attaches to top slot and provides general hardware interface Can have ROM in Pico flash

Parts:
C1, C3: C_Small; C_0805_2012Metric
J7, J8, J9, J10, J12, J13: Conn_01x10_Female; PinHeader_1x10_P2.54mm_Vertical
J11, J14: Conn_01x06_Female; PinSocket_1x06_P2.54mm_Vertical
U4: 74LS244; TSSOP-20_4.4x6.5mm_P0.65mm
U5: 74LS374; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
GND: C1.2, C3.2, J7.10, J8.10, U4.10 (GND), U5.10 (GND); also elsewhere on the board
IP0: J7.2, U4.2 (I0a)
IP1: J7.3, U4.4 (I1a)
IP2: J7.4, U4.6 (I2a)
IP3: J7.5, U4.8 (I3a)
IP4: J7.6, U4.11 (I0b)
IP5: J7.7, U4.13 (I1b)
IP6: J7.8, U4.15 (I2b)
IP7: J7.9, U4.17 (I3b)
IP_CLK: U4.1 (OEa), U4.19 (OEb); also elsewhere on the board
OP0: J8.2, U5.2 (O0)
OP1: J8.3, U5.5 (O1)
OP2: J8.4, U5.6 (O2)
OP3: J8.5, U5.9 (O3)
OP4: J8.6, U5.12 (O4)
OP5: J8.7, U5.15 (O5)
OP6: J8.8, U5.16 (O6)
OP7: J8.9, U5.19 (O7)
OP_CLK: U5.1 (OE), U5.11 (Cp); also elsewhere on the board
P_SD0: U4.18 (O0a), U5.3 (D0); also elsewhere on the board
P_SD1: U4.16 (O1a), U5.4 (D1); also elsewhere on the board
P_SD2: U4.14 (O2a), U5.7 (D2); also elsewhere on the board
P_SD3: U4.12 (O3a), U5.8 (D3); also elsewhere on the board
P_SD4: U4.9 (O0b), U5.13 (D4); also elsewhere on the board
P_SD5: U4.7 (O1b), U5.14 (D5); also elsewhere on the board
P_SD6: U4.5 (O2b), U5.17 (D6); also elsewhere on the board
P_SD7: U4.3 (O3b), U5.18 (D7); also elsewhere on the board

Notes on the sheet:
Prototyping Area
Input and output ports controlled by Pico rather than directly from control signals.

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
Board: 2 copper layers, 132.0 x 100.0 mm, 33 parts (7 on the bottom side), 67 nets.

## Commit log

2021-09-16 Added code based on (identical to) pak-gadget
2021-09-17 First working code. Comms ROM adds entry to main menu
2021-09-30 Code altered to support Pico port on top slot. This is done as per the technical manual using the states for RAM pack writing and 128K packs, which aren't supported on the top slot.
2021-10-11 Top slot changes
2021-10-13 Added input latch code
